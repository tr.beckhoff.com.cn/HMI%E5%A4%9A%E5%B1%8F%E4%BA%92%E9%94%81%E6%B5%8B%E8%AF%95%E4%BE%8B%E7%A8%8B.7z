PROGRAM MAIN
VAR
    NUM1 : UDINT;
    START : BOOL;
END_VAR

IF START THEN
    NUM1 := NUM1 + 1;
END_IF

END_PROGRAM
